## Ubuntun_test/GPIO+Button/bbb_gpio/Config.in
```kconfig
config BR2_PACKAGE_BBB_GPIO
    bool "bbb_gpio"
    help
      GPIO, Button, LED library for BeagleBone Black.
```
